// ST7789 2.0" 240x320 SPI module on the J3 header (GND VCC SCK SDA RES DC CS BL).
#include "st7789.h"
#include "board.h"
#include <ctype.h>
#include "hardware/pwm.h"
#include "hardware/spi.h"
#include "pico/stdlib.h"

#define SPI spi1

// 5x7 font, 0x20 '(space)' .. 0x5a 'Z', one byte per column, LSB at the top
static const uint8_t font[][5] = {
    {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5f,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7f,0x14,0x7f,0x14},
    {0x24,0x2a,0x7f,0x2a,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x56,0x20,0x50},{0x00,0x08,0x07,0x03,0x00},
    {0x00,0x1c,0x22,0x41,0x00},{0x00,0x41,0x22,0x1c,0x00},{0x2a,0x1c,0x7f,0x1c,0x2a},{0x08,0x08,0x3e,0x08,0x08},
    {0x00,0x80,0x70,0x30,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x00,0x60,0x60,0x00},{0x20,0x10,0x08,0x04,0x02},
    {0x3e,0x51,0x49,0x45,0x3e},{0x00,0x42,0x7f,0x40,0x00},{0x72,0x49,0x49,0x49,0x46},{0x21,0x41,0x49,0x4d,0x33},
    {0x18,0x14,0x12,0x7f,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3c,0x4a,0x49,0x49,0x31},{0x41,0x21,0x11,0x09,0x07},
    {0x36,0x49,0x49,0x49,0x36},{0x46,0x49,0x49,0x29,0x1e},{0x00,0x00,0x14,0x00,0x00},{0x00,0x40,0x34,0x00,0x00},
    {0x00,0x08,0x14,0x22,0x41},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x59,0x09,0x06},
    {0x3e,0x41,0x5d,0x59,0x4e},{0x7c,0x12,0x11,0x12,0x7c},{0x7f,0x49,0x49,0x49,0x36},{0x3e,0x41,0x41,0x41,0x22},
    {0x7f,0x41,0x41,0x41,0x3e},{0x7f,0x49,0x49,0x49,0x41},{0x7f,0x09,0x09,0x09,0x01},{0x3e,0x41,0x41,0x51,0x73},
    {0x7f,0x08,0x08,0x08,0x7f},{0x00,0x41,0x7f,0x41,0x00},{0x20,0x40,0x41,0x3f,0x01},{0x7f,0x08,0x14,0x22,0x41},
    {0x7f,0x40,0x40,0x40,0x40},{0x7f,0x02,0x1c,0x02,0x7f},{0x7f,0x04,0x08,0x10,0x7f},{0x3e,0x41,0x41,0x41,0x3e},
    {0x7f,0x09,0x09,0x09,0x06},{0x3e,0x41,0x51,0x21,0x5e},{0x7f,0x09,0x19,0x29,0x46},{0x26,0x49,0x49,0x49,0x32},
    {0x03,0x01,0x7f,0x01,0x03},{0x3f,0x40,0x40,0x40,0x3f},{0x1f,0x20,0x40,0x20,0x1f},{0x3f,0x40,0x38,0x40,0x3f},
    {0x63,0x14,0x08,0x14,0x63},{0x03,0x04,0x78,0x04,0x03},{0x61,0x59,0x49,0x4d,0x43},
};

static uint8_t madctl = 0x00;

static void cmd(uint8_t c, const uint8_t *d, int n) {
    gpio_put(PIN_LCD_CS, 0);
    gpio_put(PIN_LCD_DC, 0);
    spi_write_blocking(SPI, &c, 1);
    if (n) {
        gpio_put(PIN_LCD_DC, 1);
        spi_write_blocking(SPI, d, n);
    }
    gpio_put(PIN_LCD_CS, 1);
}

static void window(int x, int y, int w, int h) {
    uint8_t ca[4] = {x >> 8, x & 0xff, (x + w - 1) >> 8, (x + w - 1) & 0xff};
    uint8_t ra[4] = {y >> 8, y & 0xff, (y + h - 1) >> 8, (y + h - 1) & 0xff};
    cmd(0x2a, ca, 4);
    cmd(0x2b, ra, 4);
    cmd(0x2c, 0, 0);
}

static void out_pin(uint pin, bool v) {
    gpio_init(pin);
    gpio_put(pin, v);
    gpio_set_dir(pin, GPIO_OUT);
}

void lcd_rotate180(bool on) {
    madctl = on ? 0xc0 : 0x00;
    cmd(0x36, &madctl, 1);
}

void lcd_backlight(int percent) {
    if (percent < 0) percent = 0;
    if (percent > 100) percent = 100;
    pwm_set_gpio_level(PIN_LCD_BL, (uint16_t)(percent * 10));
}

void lcd_init(void) {
    spi_init(SPI, 25000000);
    spi_set_format(SPI, 8, SPI_CPOL_0, SPI_CPHA_0, SPI_MSB_FIRST);
    gpio_set_function(PIN_LCD_SCK, GPIO_FUNC_SPI);
    gpio_set_function(PIN_LCD_SDA, GPIO_FUNC_SPI);
    out_pin(PIN_LCD_CS, 1);
    out_pin(PIN_LCD_DC, 1);
    out_pin(PIN_LCD_RST, 1);
    gpio_set_function(PIN_LCD_BL, GPIO_FUNC_PWM);
    uint slice = pwm_gpio_to_slice_num(PIN_LCD_BL);
    pwm_set_wrap(slice, 1000);
    pwm_set_enabled(slice, true);
    lcd_backlight(0);

    sleep_ms(5);
    gpio_put(PIN_LCD_RST, 0);
    sleep_ms(10);
    gpio_put(PIN_LCD_RST, 1);
    sleep_ms(120);
    cmd(0x01, 0, 0);            // software reset
    sleep_ms(150);
    cmd(0x11, 0, 0);            // sleep out
    sleep_ms(120);
    cmd(0x3a, (const uint8_t[]){0x55}, 1);  // 16 bit/pixel
    cmd(0x36, &madctl, 1);      // portrait, RGB; 0xc0 = turned 180 degrees
    cmd(0x21, 0, 0);            // inversion on: these IPS modules need it for correct colours
    cmd(0x13, 0, 0);            // normal display
    lcd_fill(0, 0, LCD_W, LCD_H, C_BLACK);
    cmd(0x29, 0, 0);            // display on
    lcd_backlight(80);
}

void lcd_fill(int x, int y, int w, int h, uint16_t c) {
    if (w <= 0 || h <= 0) return;
    window(x, y, w, h);
    uint8_t line[2 * LCD_W];
    for (int i = 0; i < w; i++) { line[2 * i] = c >> 8; line[2 * i + 1] = c & 0xff; }
    gpio_put(PIN_LCD_CS, 0);
    gpio_put(PIN_LCD_DC, 1);
    for (int j = 0; j < h; j++)
        spi_write_blocking(SPI, line, 2 * w);
    gpio_put(PIN_LCD_CS, 1);
}

void lcd_test_pattern(void) {
    static const uint16_t bars[] = {C_WHITE, C_YELLOW, RGB(0, 255, 255), C_GREEN, RGB(255, 0, 255), C_RED, C_BLUE, C_BLACK};
    for (int i = 0; i < 8; i++)
        lcd_fill(i * LCD_W / 8, 0, LCD_W / 8, LCD_H - 60, bars[i]);
    for (int i = 0; i < 16; i++) {   // grey ramp
        int v = i * 17;
        lcd_fill(i * LCD_W / 16, LCD_H - 60, LCD_W / 16, 30, RGB(v, v, v));
    }
    lcd_fill(0, LCD_H - 30, LCD_W, 30, C_BLACK);
    lcd_fill(0, 0, LCD_W, 2, C_RED);            // frame: shows the panel's edges
    lcd_fill(0, LCD_H - 2, LCD_W, 2, C_RED);
    lcd_fill(0, 0, 2, LCD_H, C_RED);
    lcd_fill(LCD_W - 2, 0, 2, LCD_H, C_RED);
    lcd_text(6, LCD_H - 24, "TOP LEFT IS HERE", 2, C_WHITE, C_BLACK);
}

int lcd_text(int x, int y, const char *t, int s, uint16_t fg, uint16_t bg) {
    uint8_t buf[2 * 6 * 4 * 8 * 4];     // one glyph cell up to s = 4
    if (s < 1) s = 1;
    if (s > 4) s = 4;
    for (; *t; t++) {
        int ch = toupper((unsigned char)*t);
        if (ch < 0x20 || ch > 0x5a) ch = '?';
        const uint8_t *g = font[ch - 0x20];
        int w = 6 * s, h = 8 * s, k = 0;
        if (x + w > LCD_W) break;
        for (int row = 0; row < h; row++)
            for (int col = 0; col < w; col++) {
                int fc = col / s, fr = row / s;
                bool on = fc < 5 && fr < 7 && ((g[fc] >> fr) & 1);
                uint16_t c = on ? fg : bg;
                buf[k++] = c >> 8;
                buf[k++] = c & 0xff;
            }
        window(x, y, w, h);
        gpio_put(PIN_LCD_CS, 0);
        gpio_put(PIN_LCD_DC, 1);
        spi_write_blocking(SPI, buf, k);
        gpio_put(PIN_LCD_CS, 1);
        x += w;
    }
    return x;
}
